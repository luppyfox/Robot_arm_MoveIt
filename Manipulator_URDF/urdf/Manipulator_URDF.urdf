Commit message: V2 fix control motion planning with GAZEBO

File: Manipulator_URDF/urdf/Manipulator_URDF.urdf (robot description, URDF)
Before this commit: robot Manipulator_URDF, 9 links, 8 joints
Joints:
- joint joint4: mimic joint=joint2 multiplier=1 offset=0 -> (none)
